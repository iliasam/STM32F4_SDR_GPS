# IAR project IAR_Project.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS; ..\GPS; ..\GPS\RTK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_Project.hex
  ILINK.IlinkOutputFile: IAR_Project.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group GPS
    ../GPS/: acquisition.c common_ram.c gps_master.c gps_misc.c nav_data.c nav_data_decode.c obs_publish.c tracking.c
  group GPS/RTK
    ../GPS/RTK/: rtcm3e.c rtklib_common.c solving.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../: config.h delay_us_timer.c keys_controlling.c main.c print_state.c signal_capture.c stm32f4xx_it.c system_stm32f4xx.c uart_comm.c
